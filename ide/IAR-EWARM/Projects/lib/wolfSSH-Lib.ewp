# IAR project wolfSSH-Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: WOLFSSL_USER_SETTINGS
  ICCARM.PreInclude: stddef.h
  ICCARM.CCIncludePath2: ..; ..\..\..\..; ..\..\..\..\..\wolfssl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: wolfSSH-Lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group config
    ../: user_settings.h
  group src
    ../../../../src/: internal.c io.c keygen.c log.c port.c ssh.c wolfscp.c wolfsftp.c wolfterm.c
