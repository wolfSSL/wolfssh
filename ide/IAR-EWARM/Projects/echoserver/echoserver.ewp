# IAR project echoserver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: WOLFSSL_USER_SETTINGS
  ICCARM.CCIncludePath2: ..\..\..\..; ..\..\..\..\..\wolfssl; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: echoserver.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\wolfssl\IDE\IAR-EWARM\Projects\lib\ewarm\Exe\wolfSSL-Lib.a; ..\lib\Debug\Exe\wolfSSH-Lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../examples/echoserver/: echoserver.c
    ../: myFilesystem.c
